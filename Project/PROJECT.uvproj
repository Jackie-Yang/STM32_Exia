# Keil uVision project PROJECT.uvproj, settings and files
target PROJECT (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PROJECT +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWLIB\inc;..\Libraries\FWLIB\src;..\User;..\User\Setup;..\User\USART;..\User\Delay;..\User\TIMER;..\User\I2C_2.0;..\User\EEPROOM;..\User\GY_86\MPU6050;..\User\GY_86\MS5611;..\User\GY_86\HMC5883L;..\User\DMA;..\User\IMU;..\User\PID;..\User\filter;..\User\KS10X;..\User\GY_86\MPU6050\DMP;..\User\TIMER\LED_Blink;..\User\TIMER\Motor;..\User\TIMER\Receiver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/STARTUP/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWLIB/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c
  group USER
    ../User/: main.c
    ../User/PID/: PID.c
    ../User/IMU/: IMU.c
    ../User/filter/: filter.c
  group Driver
    ../User/I2C_2.0/: I2C.c
    ../User/TIMER/: TIMER.c
    ../User/Delay/: delay.c
    ../User/Setup/: Setup.c
    ../User/USART/: USART.c
    ../User/GY_86/MPU6050/: MPU6050.c
    ../User/EEPROOM/: eeprom.c
    ../User/GY_86/MS5611/: MS5611.c
    ../User/GY_86/HMC5883L/: HMC5883L.c
    ../User/DMA/: DMA.c
    ../User/KS10X/: KS10X.c
    ../User/GY_86/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/TIMER/LED_Blink/: LED_Blink.c
    ../User/TIMER/Motor/: Motor.c
    ../User/TIMER/Receiver/: Receiver.c
